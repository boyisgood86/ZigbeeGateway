# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\include; drivers; ..\..\components\CMSIS\Include; .; applications; ..\..\libcpu\arm\cortex-m3; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\init; ..\..\components\finsh; ..\..\components\net\lwip-1.4.1\src; ..\..\components\net\lwip-1.4.1\src\include; ..\..\components\net\lwip-1.4.1\src\arch\include; ..\..\components\net\lwip-1.4.1\src\include\ipv4; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\include; drivers; ..\..\components\CMSIS\Include; .; applications; ..\..\libcpu\arm\cortex-m3; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\init; ..\..\components\finsh; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c httpclient_yeelink.c startup.c tcp_client.c tcp_server.c udp_server.c
  group Components
    ../../components/init/: components.c
  group CORTEX-M3
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
    ../../components/drivers/serial/: serial.c
  group Doc
    ./: 说明.txt
  group Drivers
    drivers/: board.c enc28j60.c led.c stm32f10x_it.c usart.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group LwIP
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group STM32_StdPeriph
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
